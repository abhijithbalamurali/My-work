Handle (Autodesk Fusion 360 design; units mm, degrees)
derived_base_feature "Derived Base Feature" bodies "Handle"
named bodies: "Handle"